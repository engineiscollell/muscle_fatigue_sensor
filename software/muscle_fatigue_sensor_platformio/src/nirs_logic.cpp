// ============================================================================
// nirs_logic.cpp
// ============================================================================

#include "nirs_logic.h"

#include "config.h"

#include <math.h>

// ============================================================================
// CONSTANTS PRECALCULADES
// ============================================================================

static const float inv_det =
    1.0f /
    (
        (EPS_O2_RED * EPS_HB_IR) -
        (EPS_HB_RED * EPS_O2_IR)
    );

// ============================================================================
// REFERÈNCIES ÒPTIQUES
// ============================================================================

float g_I0_red = 1.0f;

float g_I0_ir = 1.0f;

// ============================================================================
// CÀLCUL NIRS
// ============================================================================

float calculateNIRS(
    const OpticalRawFrame& frame
)
{
    // ========================================================================
    // INTENSITAT NETA
    // ========================================================================

    float iRed =
        (float)frame.red -
        (float)frame.darkRed;

    float iIR =
        (float)frame.ir -
        (float)frame.darkIr;

    // ========================================================================
    // VALIDACIÓ
    // ========================================================================

    if (
        iRed <= 0.1f ||
        iIR <= 0.1f
    )
    {
        return 0.0f;
    }

    // ========================================================================
    // VARIABLES Beer-Lambert
    // ========================================================================

    float absRed = 0.0f;

    float absIR = 0.0f;

    // ========================================================================
    // SIMULACIÓ
    // COMPORTAMENT ORIGINAL
    // ========================================================================

    if (g_isSimulation)
    {
        absRed = iRed;

        absIR = iIR;
    }

    // ========================================================================
    // HARDWARE REAL
    // AMB REFERÈNCIA CALIBRADA
    // ========================================================================

    else
    {
        if (
            g_I0_red <= 0.1f ||
            g_I0_ir <= 0.1f
        )
        {
            return 0.0f;
        }

        absRed =
            -log10f(iRed / g_I0_red);

        absIR =
            -log10f(iIR / g_I0_ir);
    }

    // ========================================================================
    // MBLL
    // ========================================================================

    float relHbO2 =
        (
            absRed * EPS_HB_IR -
            absIR * EPS_HB_RED
        ) * inv_det;

    float relHb =
        (
            absIR * EPS_O2_RED -
            absRed * EPS_O2_IR
        ) * inv_det;

    // ========================================================================
    // VALIDACIÓ
    // ========================================================================

    if (
        relHbO2 < 0.0f ||
        relHb < 0.0f
    )
    {
        return 0.0f;
    }

    // ========================================================================
    // SmO2
    // ========================================================================

    float totalHb =
        relHbO2 + relHb;

    if (totalHb <= 0.00001f)
    {
        return 0.0f;
    }

    float smo2 =
        (relHbO2 / totalHb) * 100.0f;

    // ========================================================================
    // CLAMP
    // ========================================================================

    if (smo2 < 0.0f)
    {
        return 0.0f;
    }

    if (smo2 > 100.0f)
    {
        return 100.0f;
    }

    return smo2;
}